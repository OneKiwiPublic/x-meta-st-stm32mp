SUMMARY = "OneKiwi OpenSTLinux core image."
LICENSE = "Proprietary"

include recipes-st/images/st-image-weston.bb